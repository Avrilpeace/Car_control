# Keil uVision project S_bus.uvproj, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: S_bus +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CM3;..\Libraries;..\Mylib;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Library
    ../Libraries/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group Mylib
    ../Mylib/: Usart1.c Delay.c
  group User
    ../User/: stm32f10x_it.c main.c
